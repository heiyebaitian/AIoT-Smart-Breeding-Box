# Keil uVision project project.uvprojx, settings and files
target HT32 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: HT32F52352 Holtek
  pack: Holtek.HT32_DFP.1.0.54
  cpu: IROM(0x00000000-0x0001FDFF) IRAM(0x20000000-0x20003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: HT32 +hex
  AfterMake: fromelf --bin -o "#L.bin" "#L"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52352
  c include: ..\;..\..\library\CMSIS\Include;..\..\library\Device\Holtek\HT32F5xxxx\Include;..\..\library\HT32F5xxxx_Driver\inc;..\..\library\HT32_USBD_Library\inc;..\..\utilities
  asm define: USE_HT32_CHIP=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler
  group User
    ../: ht32f5xxxx_01_it.c main.c GPIO.c ADC.c USART0.c USART1.c GPTM0.c Delay.c Delay.h Control.c Control.h Soil.c Soil.h Liqiud.c Liqiud.h Motor.c Motor.h
  group Config
    ./: ht32_op.s HT32F5xxxx_01_DebugSupport.ini
    ../: ht32f5xxxx_conf.h
  group CMSIS
    ../: system_ht32f5xxxx_01.c
  group MDK-ARM
    ./: startup_ht32f5xxxx_01.s
  group Retarget
    ../../library/HT32F5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../utilities/: ht32_board.c
    ../../utilities/common/: i2c_eeprom.c spi_flash.c ebi_lcd.c
  group Library
    ../../library/Ht32F5xxxx_Driver/src/: ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_wdt.c ht32_cm0plus_misc.c ht32f5xxxx_crc.c ht32f5xxxx_rtc.c ht32f5xxxx_mctm.c ht32f5xxxx_sci.c ht32f5xxxx_usbd.c ht32f5xxxx_pdma.c ht32f5xxxx_cmp.c ht32f5xxxx_i2s.c ht32f5xxxx_ebi.c
